# Keil uVision project PruebaV1.uvproj, settings and files
target STM32F107GVCT6 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: PruebaV1 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_CL
  c include: .\STM32F10x_StdPeriph_Driver\inc;.\STM32F10x_StdPeriph_Driver\src;.\Base;..\stm32f107;.\Src;.\UserCode;.\UserCode\inc;.\UserCode\src
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ./: startup_stm32f10x_cl.s
  group STLibrary_Peripheral
    ./STM32F10x_StdPeriph_Driver/src/: stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_spi.c stm32f10x_adc.c stm32f10x_dma.c
  group Base
    ./Base/: stm32f10x.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h system_stm32f10x.c system_stm32f10x.h
  group Source
    ./Src/: main.c main.h
  group UserLibrary
    ./UserCode/src/: header_hardware.c fonts.c
